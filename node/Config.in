## node/Config.in
```kconfig
menu "Module Selection"

config NODEJS_ICU_SUPPORT
	bool "icu support"
	default y

endmenu
```
